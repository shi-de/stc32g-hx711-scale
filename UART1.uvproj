# Keil uVision project UART1.uvproj, settings and files
target UART1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: UART1 +hex
  group Source
    ./: UART1.c isr.asm hx711.c scale_math.c
